# Keil uVision project ble_oxymeter.uvprojx, settings and files
target BIO_SPO2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_dtm;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\ble_racp;..\..\components\ble\ble_services\ble_ancs_c;..\..\components\ble\ble_services\ble_ans_c;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_bas_c;..\..\components\ble\ble_services\ble_cscs;..\..\components\ble\ble_services\ble_cts_c;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\ble_services\ble_dis;..\..\components\ble\ble_services\ble_gls;..\..\components\ble\ble_services\ble_hids;..\..\components\ble\ble_services\ble_hrs;..\..\components\ble\ble_services\ble_hrs_c;..\..\components\ble\ble_services\ble_hts;..\..\components\ble\ble_services\ble_ias;..\..\components\ble\ble_services\ble_ias_c;..\..\components\ble\ble_services\ble_lbs;..\..\components\ble\ble_services\ble_lbs_c;..\..\components\ble\ble_services\ble_lls;..\..\components\ble\ble_services\ble_nus;..\..\components\ble\ble_services\ble_nus_c;..\..\components\ble\ble_services\ble_rscs;..\..\components\ble\ble_services\ble_rscs_c;..\..\components\ble\ble_services\ble_tps;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\peer_manager;..\..\components\boards;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\bootloader\ble_dfu;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\cli;..\..\components\libraries\crc16;..\..\components\libraries\crc32;..\..\components\libraries\crypto;..\..\components\libraries\csense;..\..\components\libraries\csense_drv;..\..\components\libraries\delay;..\..\components\libraries\ecc;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fds;..\..\components\libraries\fifo;..\..\components\libraries\fstorage;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\led_softblink;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\mpu;..\..\components\libraries\mutex;..\..\components\libraries\pwm;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\sdcard;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\twi_mngr;..\..\components\libraries\twi_sensor;..\..\components\libraries\uart;..\..\components\libraries\usbd;..\..\components\libraries\usbd\class\audio;..\..\components\libraries\usbd\class\cdc;..\..\components\libraries\usbd\class\cdc\acm;..\..\components\libraries\usbd\class\hid;..\..\components\libraries\usbd\class\hid\generic;..\..\components\libraries\usbd\class\hid\kbd;..\..\components\libraries\usbd\class\hid\mouse;..\..\components\libraries\usbd\class\msc;..\..\components\libraries\util;..\..\components\nfc\ndef\conn_hand_parser;..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\components\nfc\ndef\connection_handover\common;..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\components\nfc\ndef\generic\message;..\..\components\nfc\ndef\generic\record;..\..\components\nfc\ndef\launchapp;..\..\components\nfc\ndef\parser\message;..\..\components\nfc\ndef\parser\record;..\..\components\nfc\ndef\text;..\..\components\nfc\ndef\uri;..\..\components\nfc\platform;..\..\components\nfc\t2t_lib;..\..\components\nfc\t2t_parser;..\..\components\nfc\t4t_lib;..\..\components\nfc\t4t_parser\apdu;..\..\components\nfc\t4t_parser\cc_file;..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\components\nfc\t4t_parser\tlv;..\..\components\softdevice\common;..\..\components\softdevice\s132\headers;..\..\components\softdevice\s132\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\source;..\config;C:\Keil_v5\ARM\PACK\NordicSemiconductor\nRF_DeviceFamilyPack\8.35.0\Device\Include;..\components\lvgl\src;..\components\lvgl\src;..\components\lvgl\src/core;..\components\lvgl\src/draw;..\components\lvgl\src/extra;..\components\lvgl\src/font;..\components\lvgl\src/gpu;..\components\lvgl\src/hal;..\components\lvgl\src/misc;..\components\lvgl\src/widgets;..\components\lvgl\src/extra/layouts;..\components\lvgl\src/extra/layouts/flex;..\components\lvgl\src/extra/layouts/grid;..\components\lvgl\src/extra/themes;..\components\lvgl\src/extra/themes/basic;..\components\lvgl\src/extra/themes/default;..\components\lvgl\src/extra/widgets/calendar;..\components\lvgl\src/extra/widgets/colorwheel;..\components\lvgl\src/extra/widgets;..\components\lvgl\src/extra/widgets/imgbtn;..\components\lvgl\src/extra/widgets/keyboard;..\components\lvgl\src/extra/widgets/led;..\components\lvgl\src/extra/widgets/list;..\components\lvgl\src/extra/widgets/msgbox;..\components\lvgl\src/extra/widgets/spinbox;..\components\lvgl\src/extra/widgets/spinner;..\components\lvgl\src/extra/widgets/tabview;..\components\lvgl\src/extra/widgets/tileview;..\components\lvgl\src/extra/widgets/w;..\source\lcd_image
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=7,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_dtm;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\ble_racp;..\..\components\ble\ble_services\ble_ancs_c;..\..\components\ble\ble_services\ble_ans_c;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_bas_c;..\..\components\ble\ble_services\ble_cscs;..\..\components\ble\ble_services\ble_cts_c;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\ble_services\ble_dis;..\..\components\ble\ble_services\ble_gls;..\..\components\ble\ble_services\ble_hids;..\..\components\ble\ble_services\ble_hrs;..\..\components\ble\ble_services\ble_hrs_c;..\..\components\ble\ble_services\ble_hts;..\..\components\ble\ble_services\ble_ias;..\..\components\ble\ble_services\ble_ias_c;..\..\components\ble\ble_services\ble_lbs;..\..\components\ble\ble_services\ble_lbs_c;..\..\components\ble\ble_services\ble_lls;..\..\components\ble\ble_services\ble_nus;..\..\components\ble\ble_services\ble_nus_c;..\..\components\ble\ble_services\ble_rscs;..\..\components\ble\ble_services\ble_rscs_c;..\..\components\ble\ble_services\ble_tps;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\peer_manager;..\..\components\boards;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\bootloader\ble_dfu;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\cli;..\..\components\libraries\crc16;..\..\components\libraries\crc32;..\..\components\libraries\crypto;..\..\components\libraries\csense;..\..\components\libraries\csense_drv;..\..\components\libraries\delay;..\..\components\libraries\ecc;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fds;..\..\components\libraries\fifo;..\..\components\libraries\fstorage;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\led_softblink;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\mpu;..\..\components\libraries\mutex;..\..\components\libraries\pwm;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\sdcard;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\twi_mngr;..\..\components\libraries\twi_sensor;..\..\components\libraries\uart;..\..\components\libraries\usbd;..\..\components\libraries\usbd\class\audio;..\..\components\libraries\usbd\class\cdc;..\..\components\libraries\usbd\class\cdc\acm;..\..\components\libraries\usbd\class\hid;..\..\components\libraries\usbd\class\hid\generic;..\..\components\libraries\usbd\class\hid\kbd;..\..\components\libraries\usbd\class\hid\mouse;..\..\components\libraries\usbd\class\msc;..\..\components\libraries\util;..\..\components\nfc\ndef\conn_hand_parser;..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\components\nfc\ndef\connection_handover\common;..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\components\nfc\ndef\generic\message;..\..\components\nfc\ndef\generic\record;..\..\components\nfc\ndef\launchapp;..\..\components\nfc\ndef\parser\message;..\..\components\nfc\ndef\parser\record;..\..\components\nfc\ndef\text;..\..\components\nfc\ndef\uri;..\..\components\nfc\platform;..\..\components\nfc\t2t_lib;..\..\components\nfc\t2t_parser;..\..\components\nfc\t4t_lib;..\..\components\nfc\t4t_parser\apdu;..\..\components\nfc\t4t_parser\cc_file;..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\components\nfc\t4t_parser\tlv;..\..\components\softdevice\common;..\..\components\softdevice\s132\headers;..\..\components\softdevice\s132\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002ad8 size 0xd528
  link misc: --diag_suppress 6330
  group Application
    ../config/: sdk_config.h
    ../source/: main.c ob1203.c max30205.c sys_temp.c sys_bm.c spo2.c kalman.c sys_po.c gc9a01.c bsp.c bsp_lcd.c
  group Board Definition
    ../../components/boards/: boards.c
  group Board Support
    ../../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../source/: ble_blood_oxygen_service.c ble_heart_rate_service.c ble_body_temp_service.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c nrf_drv_twi.c nrf_drv_spi.c
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_twi.c nrfx_saadc.c nrfx_spi.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c nrf_log_backend_uart.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group Components
    ../components/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../components/lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../components/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../components/lvgl/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../components/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../components/lvgl/src/extra/: lv_extra.c
    ../components/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../components/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../components/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../components/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../components/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../components/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../components/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../components/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../components/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../components/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../components/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../components/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../components/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../components/lvgl/src/extra/widgets/led/: lv_led.c
    ../components/lvgl/src/extra/widgets/list/: lv_list.c
    ../components/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../components/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../components/lvgl/src/extra/widgets/span/: lv_span.c
    ../components/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../components/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../components/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../components/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../components/lvgl/src/extra/widgets/win/: lv_win.c
target BIO_TEMP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: as above
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: TEMPERATURE_BOARD APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002ad8 size 0xd528
  link misc: --diag_suppress 6330
target flash_s132_nrf52_7.2.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: as above
  output: s132_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002ad8 size 0xd528
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, CMSIS:CORE 5.5.0, Device:Startup 8.35.0, Device:Startup 8.38.0
